# Keil uVision project A610.uvproj, settings and files
target A610 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LG-06-CTR +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ../output/LG-06-CTR.bin ../output/LG-06-CTR.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F030x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Src\User\include
  library: MicroLIB
  memory RVCT4: ROM 0x8001800 size 0xe000
  memory RVCT9: RAM 0x200000c4 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_it.c
    ../Src/User/: uart.c flash.c config.c orbital.c keyscan.c GPIO.c oled.c Pair.c RF24L01.c low_power.c bootloader.c UID_Encryption.c ab_set.c ADC.c specialty_mode.c video.c RTC.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_adc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_ll_rcc.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_dma.c stm32f0xx_ll_pwr.c stm32f0xx_ll_gpio.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_hal_pwr.c
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
